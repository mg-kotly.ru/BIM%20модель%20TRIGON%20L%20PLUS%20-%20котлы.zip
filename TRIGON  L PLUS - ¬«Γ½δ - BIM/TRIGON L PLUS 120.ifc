Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2020-06-30T13:32:27
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170223_1515(x64) - Exporter 18.0.0.420 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Jun 30 13:32:27 2020 * Host: CRAICA-RO-DE * Database: C:\Users\CRaica\AppData\Local\Temp\{06E03C6D-1030-49A4-934B-9C4EB42021C6}\ifc * Database version: 5507 * Database creation date: Tue Jun 30 13:32:26 2020 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Tue Jun 30 13:32:26 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Jun 30 13:32:26 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Other - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Other - Category: Project Information

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: Level 1; Family and Type: Level: Level 1; Type: Level: Level 1; Type Id: Level: Level 1
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Level 1

# IfcBoiler: TRIGON L PLUS 120, HC_Boiler_MEPcontent_Elco_TRIGON L PLUS 120_INT-EN:TRIGON L PLUS 120:159739
In: Level 1
Type - PredefinedType: WATER; Material: Color RGB 049-049-049, Color RGB 216-216-216, Color RAL 9016, Color RGB 172-184-196
Type - Dimensions - Depth: 590 mm; Drain Diameter: 32 mm; Flue Gas Diameter: 100 mm; Gas Diameter: 28.6 mm; Height: 1050 mm; Hydronic Return Diameter: 45 mm; Hydronic Supply Diameter: 45 mm; Supply Air Diameter: 100 mm; Use Nominal Diameter: yes; Width: 690 mm
Type - Electrical - Electrical Connection: 230 V; Frequency: 50 Hz; Hertz: 50 Hz; IP Class: IPX4D; Mains Connection Fuse: 6.3 A; Phase: 1; Power Consumption Boiler max ErP (Incl. Pump): 314 W; Power Consumption Boiler min ErP (Incl. Pump): 66 W; Voltage: 230 V
Type - General - CE Certification Code: 0063CT3449; Maximum Gas Pressure: 5750000000 Pa; Min Gas Pressure H-gas: 1700000000 Pa; Min Gas Pressure L-gas: 2000000000 Pa; Min Gas Pressure LPG (mbar): 25-35; Minimum Heat Input Hi min: 14900 W; Minimum Heat Output at 40/30ºC: 16200 W; Minimum Heat Output at 50/30ºC: 16100 W; Minimum Heat Output at 75-60ºC: 14700 W; Minimum Heat Output at 80-60ºC: 14700 W; Modulation: 8; Noise Level (dB(A)): 67.3; Nominal Heat Input Hi max: 112800 W; Nominal Heat Output at 40/30ºC: 122200 W; Nominal Heat Output at 50/30ºC: 122000 W; Nominal Heat Output at 75-60ºC: 110400 W; Nominal Heat Output at 80-60ºC: 110800 W; Sound Pressure Level (dB(A)): 56.3; Weight (empty): 127
Type - Identity Data - Article Description: Boiler 120kW floor standing; Article Type: TRIGON L PLUS 120; Base Family Version: 12.15; Content Supplier URL: www.MEPcontent.com; Copyright: © Stabiplan International BV; Custom: no; Description: Boiler 120kW floor standing; EMCS Version: 4.0; ETIM Article Class: EC011396; Family Version: 12.09; Manufacturer: Elco; Manufacturer URL: http://www.elco.net/; MEPcontent Class: BOILER; Model: TRIGON L PLUS 120; OmniClass Number: 23.75.10.11.14; OmniClass Title: Hot Water Heat Generators; Product Line: Elco; Revit Version: 2018; Type Name: TRIGON L PLUS 120; URL: www.stabiplan.com; Watermarked By: www.stabiplan.com
Type - Materials and Finishes - Black: Color RGB 049-049-049; Light Grey: Color RGB 172-184-196; Light White: Color RAL 9016; White: Color RGB 216-216-216
Type - Mechanical - Hydraulic Resistance at Nominal Water Flow: 23300 Pa; Hydraulic Resistance at Nominal Water Flow (dT 25K): 15000 Pa; Max. Condensate (full load @ 40/30ºC, 20ºC ambient, G20): 0.448496 m3/s; Max. Permissible Flue Resistance max: 143 Pa; Maximum Available Head for System: 26200 Pa; Maximum Temperature Setpoint: 90 kg/K/s3; Maximum Water Temperature (High Limit Thermostat): 95 kg/K/s3; Nominal Power 50-30°C: 0; Nominal Power 80-60°C: 0; Nominal Water Flow at dT=20K: 0.0470862 m3/s; Nominal Water Flow at dT=25K: 0.0377671 m3/s; NOx Class: 6; Tap Capacity at 60°C: 0 m3/s; Total Head at Nominal Flow: 49500 Pa; Volume: 0 m3; Water Pressure max: 600000 Pa; Water Pressure min: 70000 Pa; Water Volume: 0.0168 m3; ΔT max (K): 30
Type - Other - Category: Mechanical Equipment; Family Name: HC_Boiler_MEPcontent_Elco_TRIGON L PLUS 120_INT-EN
Pset_ManufacturerTypeInformation - Manufacturer: Elco
Constraints - Offset: 0 mm
Dimensions - Area: 1.84072 m2; Legs Height: 50 mm; Volume: 0.440171 m3
Electrical - Power: 314 W
Identity Data - Mark: 1
Mechanical - System Classification: Supply Air,Undefined,Sanitary,Hydronic Return,Hydronic Supply,Power,Other
Mechanical - Flow - Drain Fixture Units: 0; Flue Gas Flow: 0 m3/s; Gas Flow: 0 m3/s; Hydronic Return Flow: 0 m3/s; Hydronic Supply Flow: 0 m3/s; Supply Air Flow: 0 m3/s
Other - Family: HC_Boiler_MEPcontent_Elco_TRIGON L PLUS 120_INT-EN: TRIGON L PLUS 120; Family and Type: HC_Boiler_MEPcontent_Elco_TRIGON L PLUS 120_INT-EN: TRIGON L PLUS 120; Legs Height 2 Safe: 30 mm; Legs Height Safe: 50 mm; Type: HC_Boiler_MEPcontent_Elco_TRIGON L PLUS 120_INT-EN: TRIGON L PLUS 120; Type Id: HC_Boiler_MEPcontent_Elco_TRIGON L PLUS 120_INT-EN: TRIGON L PLUS 120
Phasing - Phase Created: New Construction
