Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2020-08-12T15:09:01
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170223_1515(x64) - Exporter 18.0.0.420 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Aug 12 15:09:01 2020 * Host: PROMAN1-RO-DE * Database: C:\Users\PRoman1\AppData\Local\Temp\{0742F102-6488-4C42-B30F-FEA33730F23D}\ifc * Database version: 5507 * Database creation date: Wed Aug 12 15:09:00 2020 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Wed Aug 12 15:09:00 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Aug 12 15:09:00 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 23, 13, 199999; RefLongitude: -71, -14, -31, -199999; RefElevation: 0 mm
Dimensions - S4R_Use_nominal_diameter: yes
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Dimensions - S4R_Use_nominal_diameter: yes
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, V00
LongName: V00; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: Floor Level
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: GE_tag_level_floor_MEPcontent: standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: yes
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: V00; Structural: no
Other - Category: Levels; Family: Level: Floor Level; Family and Type: Level: Floor Level; Type: Level: Floor Level; Type Id: Level: Floor Level
Constraints(Type) - Elevation Base: Project Base Point

# IfcBoiler: TRIGON L PLUS 60, HC_Boiler_MEPcontent_Elco_TRIGON L PLUS 60_INT-EN:TRIGON L PLUS 60:1289827
In: V00
Type - PredefinedType: WATER; Material: Color RGB 216-216-216, Color RGB 049-049-049, Color RAL 9016, Color RGB 172-184-196
Type - Dimensions - Depth: 590 mm; Drain Diameter: 32 mm; Flue Gas Diameter: 100 mm; Gas Diameter: 28.6 mm; Height: 1050 mm; Hydronic Return Diameter: 45 mm; Hydronic Supply Diameter: 45 mm; Supply Air Diameter: 100 mm; Use Nominal Diameter: yes; Width: 530 mm
Type - Electrical - Electrical Connection: 230 V; Frequency: 50 Hz; Hertz: 50 Hz; IP Class: IPX4D; Mains Connection Fuse: 6.3 A; Phase: 1; Power Consumption Boiler max ErP (Incl. Pump): 126 W; Power Consumption Boiler min ErP (Incl. Pump): 81 W; Voltage: 230 V
Type - General - CE Certification Code: 0063CT3449; Maximum Gas Pressure: 5750 Pa; Min Gas Pressure H-gas: 1700 Pa; Min Gas Pressure L-gas: 2000 Pa; Min Gas Pressure LPG (mbar): 25-35; Minimum Heat Input Hi min: 14900 W; Minimum Heat Output at 40/30ºC: 16100 W; Minimum Heat Output at 50/30ºC: 16100 W; Minimum Heat Output at 75-60ºC: 14700 W; Minimum Heat Output at 80-60ºC: 14700 W; Modulation: 4; Noise Level (dB(A)): 62; Nominal Heat Input Hi max: 57900 W; Nominal Heat Output at 40/30ºC: 62600 W; Nominal Heat Output at 50/30ºC: 62500 W; Nominal Heat Output at 75-60ºC: 57000 W; Nominal Heat Output at 80-60ºC: 56900 W; Sound Pressure Level (dB(A)): 51; Weight (empty): 73
Type - Identity Data - Article Description: Boiler 60kW floor standing; Article Type: TRIGON L PLUS 60; Base Family Version: 12.17; Content Supplier URL: www.MEPcontent.com; Copyright: © Stabiplan International BV; Custom: no; Description: Boiler 60kW floor standing; EMCS Version: 4.0; ETIM Article Class: EC011396; Family Version: 12.17; Manufacturer: Elco; Manufacturer URL: http://www.elco.net/; MEPcontent Class: BOILER; Model: TRIGON L PLUS 60; OmniClass Number: 23.75.10.11.14; OmniClass Title: Hot Water Heat Generators; Product Line: Elco; Revit Version: 2018; Type Name: TRIGON L PLUS 60; URL: www.stabiplan.com; Watermarked By: www.stabiplan.com
Type - Materials and Finishes - Black: Color RGB 049-049-049; Light Grey: Color RGB 172-184-196; Light White: Color RAL 9016; White: Color RGB 216-216-216
Type - Mechanical - Hydraulic Resistance at Nominal Water Flow: 18300 Pa; Hydraulic Resistance at Nominal Water Flow (dT 25K): 11700 Pa; Max. Condensate (full load @ 40/30ºC, 20ºC ambient, G20): 0.00000177778 m3/s; Max. Permissible Flue Resistance max: 161 Pa; Maximum Available Head for System: 30000 Pa; Maximum Temperature Setpoint: 90 kg/K/s3; Maximum Water Temperature (High Limit Thermostat): 95 kg/K/s3; Nominal Power 50-30°C: 0; Nominal Power 80-60°C: 0; Nominal Water Flow at dT=20K: 0.000666667 m3/s; Nominal Water Flow at dT=25K: 0.000541667 m3/s; NOx Class: 6; Tap Capacity at 60°C: 0 m3/s; Total Head at Nominal Flow: 48000 Pa; Volume: 0 m3; Water Pressure max: 600000 Pa; Water Pressure min: 70000 Pa; Water Volume: 0.0093 m3; ΔT max (K): 30
Type - Other - Category: Mechanical Equipment; Family Name: HC_Boiler_MEPcontent_Elco_TRIGON L PLUS 60_INT-EN
Pset_ManufacturerTypeInformation - Manufacturer: Elco
Constraints - Offset: 0 mm
Dimensions - Area: 1.57535 m2; Legs Height: 50 mm; Volume: 0.338552 m3
Electrical - Loads - Power: 126 W
Identity Data - Design Option: Main Model; Mark: 4
Mechanical - System Classification: Supply Air,Undefined,Sanitary,Hydronic Return,Hydronic Supply,Power,Other
Mechanical - Flow - Drain Fixture Units: 0; Flue Gas Flow: 0 m3/s; Gas Flow: 0 m3/s; Hydronic Return Flow: 0 m3/s; Hydronic Supply Flow: 0 m3/s; Supply Air Flow: 0 m3/s
Other - Family: HC_Boiler_MEPcontent_Elco_TRIGON L PLUS 60_INT-EN: TRIGON L PLUS 60; Family and Type: HC_Boiler_MEPcontent_Elco_TRIGON L PLUS 60_INT-EN: TRIGON L PLUS 60; Legs Height 2 Safe: 30 mm; Legs Height Safe: 50 mm; Type: HC_Boiler_MEPcontent_Elco_TRIGON L PLUS 60_INT-EN: TRIGON L PLUS 60; Type Id: HC_Boiler_MEPcontent_Elco_TRIGON L PLUS 60_INT-EN: TRIGON L PLUS 60
Phasing - Phase Created: 3. New Construction
